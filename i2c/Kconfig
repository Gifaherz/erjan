## i2c/Kconfig
```kconfig
config I2C_DISP
        tristate "I2C adapter"
	help
	  If you say yes to this option, support will be included for the
	  I2C interface.
```
